# Keil uVision project PeristalticDeom.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RE GigaDevice
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PeristalticDeom
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: .\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\CMSIS\include;.\Peripherals\Include;..\peristalticDemo;.\User;.\Public
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_gd32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_gd32f10x.c
  group StdPeriph_Driver
    ./Peripherals/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rtc.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_rcu.c
  group FreeRTOS
    ./FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group User
    ./User/: main.c gd32f10x_it.c gd32f10x_it.h
  group Public
    ./Public/: systick.c systick.h
  group port
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
